# Keil uVision project stm32f429_RA6963.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f429_RA6963
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F427_437xx
  c include: ..\..\..\PP_Library_C_hub\PP_Delay;..\..\..\PP_Library_C_hub\PP_Hardware_Library;..\..\..\PP_Library_C_hub\PP_LCDgraph_Library;..\..\..\PP_Library_C_hub\PP_Pins;.;..\..\..\PP_Library_C_hub\PP_CheckSignals_Library
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ../../../PP_Library_C_hub/PP_Delay/: delay.c
    ../../../PP_Library_C_hub/PP_Hardware_Library/: lcd_font.c lcd_icons.c t6963.c
    ../../../PP_Library_C_hub/PP_LCDgraph_Library/: pp_lcdgraph.c
    ./: config.c main.c stm32f_it.c input_signals.h
    ../../../PP_Library_C_hub/PP_Pins/: def_pins_stm32f4.h
    ../../../PP_Library_C_hub/PP_CheckSignals_Library/: pp_signals.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
